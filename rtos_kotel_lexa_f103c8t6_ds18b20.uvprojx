# Keil uVision project rtos_kotel_lexa_f103c8t6_ds18b20.uvprojx, settings and files
target rtos_kotel_lexa_f103c8t6_ds18b20 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtos_kotel_lexa_f103c8t6_ds18b20 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\rtos\include;.\rtos;.\source
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./source/: 1wire.c init_hard.c main.c ssd1306.c
    ./rtos/include/: FreeRTOS.h
  group rtos
    ./rtos/: croutine.c event_groups.c heap_1.c list.c port.c queue.c stream_buffer.c tasks.c timers.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
